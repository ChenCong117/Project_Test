# Keil uVision project Mx5530_Firmware_RevA.uvproj, settings and files
target MX5530_Firmware_RevA (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ..\out_hex\FW +hex
  AfterMake: .\\post_exe\\HEX2BIN2.0 .\\out_hex\\FW.hex
  AfterMake: .\\post_exe\\CT367_BIN2DAT .\\out_hex\\FW.bin .\\out_bin\\Mx5330FW.dat
  c flags: Optimize=8
  c include: ./src/include;./src/drivers;./src/lib;./src/modules;./src/events;./src
  group include
    ./src/include/: includes.h typedef.h reg_def.h system_cfg.h compile_cfg.h mem_layout.h
  group application
    ./src/application/: main.c STARTUP.A51 sched.c
  group drivers
    ./src/drivers/sw_iic/: sw_iic.c
    ./src/drivers/timer/: timer.c
    ./src/drivers/power/: power.c
  group lib
    ./src/lib/interrupt/: interrupt.c
    ./src/lib/sw_delay/: sw_delay.c
    ./src/lib/system/: system.c
  group test
    ./src/test/: test_main.c
  group usb_pd
    ./src/modules/usb_pd/usbpd/: usb_pd.c usbpd_policy.c usbpd_protocol.c
  group events
    ./src/events/: callback.c event_tiny.c event.c
  group linker
    ./: linker.lin
